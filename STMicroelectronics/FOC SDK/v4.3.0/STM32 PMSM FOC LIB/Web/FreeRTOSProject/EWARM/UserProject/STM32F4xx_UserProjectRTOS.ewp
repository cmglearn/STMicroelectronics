# IAR project STM32F4xx_UserProjectRTOS.ewp, settings and files
configuration STM324xG-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX; USE_STM324xG_EVAL; ARM_MATH_CM4; FREE_RTOS
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\\CMSIS_2_x\Device\ST\STM32F4xx\Include; ..\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM3240_41_G_EVAL; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\..\Common\Libraries\FreeRTOS Source\include; ..\..\..\..\Common\Libraries\FreeRTOS Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\Common\Libraries\FreeRTOS Source\include
  OBJCOPY.OOCOutputFile: UserProject.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STEVAL-IHM039V1_DUALDRIVE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX; USE_STM32F4XX_DUAL; ARM_MATH_CM4; FREE_RTOS
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\\CMSIS_2_x\Device\ST\STM32F4xx\Include; ..\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM32F4xx_dual; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\..\Common\Libraries\FreeRTOS Source\include; ..\..\..\..\Common\Libraries\FreeRTOS Source\portable\IAR\ARM_CM4F
configuration STEVAL-IHM039V1_SINGLEDRIVE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
configuration STM32446E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F446xx; USE_STM32446E_EVAL; ARM_MATH_CM4; FREE_RTOS
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\\CMSIS_2_x\Device\ST\STM32F4xx\Include; ..\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM32446E_EVAL; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\..\Common\Libraries\FreeRTOS Source\include; ..\..\..\..\Common\Libraries\FreeRTOS Source\portable\IAR\ARM_CM4F
configuration STM32F446_DUAL_DRIVE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F446xx; ARM_MATH_CM4; FREE_RTOS
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include; ..\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\..\Common\Libraries\FreeRTOS Source\include; ..\..\..\..\Common\Libraries\FreeRTOS Source\portable\IAR\ARM_CM4F
  group (top)
    ../../: GAPApplication.c GAPApplication.h main.c stm32f4xx_it.c Timebase.c UITask.c
    ../../../: readme.txt
    ../../../SystemDriveParams/: stm32f4xx_MC_it.c
  group Motor control/MC Application/interface
    ../../../MCApplication/interface/: MC.h MCInterfaceClass.h MCTasks.h MCTuningClass.h
  group Motor control/MC Application/private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group Motor control/MC Application/src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group Motor control/MC Library/interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HALL_SpeednPosFdbkClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h ICS_DD_PWMnCurrFdbkClass.h ICS_F4XX_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_DD_PWMnCurrFdbkClass.h R1_F4XX_PWMnCurrFdbkClass.h R3_DD_PWMnCurrFdbkClass.h R3_F4XX_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group Motor control/MC Library/interface/common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group Motor control/MC Library/lib
    ../MC Library Compiled/Exe/: MC_Library_STM32F4xx_dual_drive.a MC_Library_STM32F4xx_single_drive.a
  group Motor control/System & Drive Params
    ../../../SystemDriveParams/: Parameters conversion_F4xx motor 2.h Parameters conversion_F4xx.h SystemNDriveParams.h
  group Motor control/System & Drive Params/Motor1
    ../../../SystemDriveParams/: Control stage parameters.h Drive parameters.h Parameters conversion.h PMSM motor parameters.h Power stage parameters.h
  group Motor control/System & Drive Params/Motor2
    ../../../SystemDriveParams/: Control stage parameters motor 2.h Drive parameters motor 2.h Parameters conversion motor 2.h PMSM motor 2 parameters.h Power stage parameters motor 2.h
  group RTOS
    ../../../../Common/Libraries/FreeRTOS Source/: croutine.c list.c queue.c tasks.c
    ../../../../Common/Libraries/FreeRTOS Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c
    ../../../../Common/Libraries/FreeRTOS Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group RTOS/Config
    ../../../../Common/Libraries/FreeRTOS Source/include/: FreeRTOSConfig.h
  group Std project template/CMSIS
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_init_f32.c
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Std project template/Doc
    ./: readme.txt
  group Std project template/EWARMv5_F4XX
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group Std project template/StdPeriph_Driver_F4XX
    ../../../../Common/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Std project template/STM32_EVAL/STM32446E-EVAL
    ../../../../Common/Libraries/STM32_EVAL/STM32446E_EVAL/: stm32446e_eval.c stm32446e_eval_ioe.c stm32446e_eval_lcd.c
  group Std project template/STM32_EVAL/STM324xG-EVAL
    ../../../../Common/Libraries/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c
  group Std project template/STM32_EVAL/STM32F4xx_dual
    ../../../../Common/Libraries/STM32_EVAL/STM32F4XX_DUAL/: STM32F4xx_dual.c STM32F4xx_dual_lcd.c
  group User interface/UI Library/interface
    ../../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h LCDVintage_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h UnidirectionalFastCom_UserInterfaceClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group User interface/UI Library/private
    ../../../UILibrary/inc/: DAC_UserInterfacePrivate.h DACRCTIMER_UserInterfacePrivate.h DACSPI_UserInterfacePrivate.h DACSPIAD7303_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCDManager_UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h UnidirectionalFastCom_UserInterfacePrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h
  group User interface/UI Library/src
    ../../../UILibrary/src/: DAC_F4XX_UserInterfaceClass.c FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c LCDVintage_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c UnidirectionalFastCom_F4XX_UserInterfaceClass.c USART_F4XX_PhysicalLayerCommunication_Class.c UserInterfaceClass.c
