# IAR project STM32F2xx_MC Library.ewp, settings and files
configuration STM32F2xx_SINGLE_DRIVE (ARM)
  General.OGChipSelectEditMenu: STM32F217ZG ST STM32F217ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; MC_LIBRARY_SINGLE
  ICCARM.CCIncludePath2: ..\; ..\..\MCLibrary\; ..\..\MCLibrary\inc\; ..\..\MCLibrary\interface\; ..\..\MCLibrary\interface\common\; ..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F2xx\Include; ..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MC architecture.srec
  ILINK.IlinkOutputFile: MC architecture.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F2xx_DUAL_DRIVE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; MC_LIBRARY_DUAL
  group (top)
    ../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F2xx/Include/: stm32f2xx.h
  group MC Library
    ../../MCLibrary/: MCLibraryConf.h stm32f2xx_MisraCompliance.h
  group MC Library/interface
    ../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HALL_SpeednPosFdbkClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h ICS_F2XX_PWMnCurrFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_F2XX_PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_F2XX_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group MC Library/interface/common
    ../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h RampExtMngrClass.h RampMngrClass.h
  group MC Library/obj/Dual Drive
    ../../MCLibrary/obj/Dual Drive/: FeedForwardCtrlClass.o FluxWeakeningCtrlClass.o MTPACtrlClass.o RevupCtrlClass.o STO_CORDIC_SpeednPosFdbkClass.o STO_SpeednPosFdbkClass.o
  group MC Library/obj/Single Drive
    ../../MCLibrary/obj/Single Drive/: FeedForwardCtrlClass.o FluxWeakeningCtrlClass.o MTPACtrlClass.o RevupCtrlClass.o STO_CORDIC_SpeednPosFdbkClass.o STO_SpeednPosFdbkClass.o
  group MC Library/private
    ../../MCLibrary/inc/: BusVoltageSensorPrivate.h DigitalOutputPrivate.h ENC_F2xx_SpeednPosFdbkPrivate.h EncAlignCtrlPrivate.h HALL_F2xx_SpeednPosFdbkPrivate.h ICS_F2XX_PWMnCurrFdbkPrivate.h InrushCurrentLimiterPrivate.h MCIRQHandlerPrivate.h MotorPowerMeasurementPrivate.h NTC_TemperatureSensorPrivate.h PID_PIRegulatorPrivate.h PIRegulatorPrivate.h PQD_MotorPowerMeasurementPrivate.h PWMnCurrFdbkPrivate.h R1_F2XX_PWMnCurrFdbkPrivate.h R3_F2XX_PWMnCurrFdbkPrivate.h RampExtMngrPrivate.h RampMngrPrivate.h Rdivider_BusVoltageSensorPrivate.h SpeednPosFdbkPrivate.h SpeednTorqCtrlPrivate.h StateMachinePrivate.h TemperatureSensorPrivate.h Virtual_BusVoltageSensorPrivate.h Virtual_TemperatureSensorPrivate.h VirtualSpeedSensor_SpeednPosFdbkPrivate.h
  group MC Library/src
    ../../MCLibrary/src/: BusVoltageSensorClass.c CircleLimitationClass.c DigitalOutputClass_F2XX.c ENC_F2xx_SpeednPosFdbkClass.c EncAlignCtrlClass.c HALL_F2xx_SpeednPosFdbkClass.c ICS_F2XX_PWMnCurrFdbkClass.c InrushCurrentLimiterClass.c MC_Math.c MCIRQHandlerClass.c MotorPowerMeasurementClass.c NTC_TemperatureSensorClass.c OpenLoopClass.c PID_PIRegulatorClass.c PIRegulatorClass.c PQD_MotorPowerMeasurementClass.c PWMnCurrFdbkClass.c R1_F2XX_PWMnCurrFdbkClass.c R3_F2XX_PWMnCurrFdbkClass.c RampExtMngrClass.c RampMngrClass.c Rdivider_BusVoltageSensorClass.c SpeednPosFdbkClass.c SpeednTorqCtrlClass.c StateMachineClass.c TemperatureSensorClass.c Virtual_BusVoltageSensorClass.c Virtual_TemperatureSensorClass.c VirtualSpeedSensor_SpeednPosFdbkClass.c
