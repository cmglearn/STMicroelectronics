# IAR project STM32F10x_PFC_Project.ewp, settings and files
configuration RELEASE (ARM)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_DAC; USE_LCD
  ICCARM.CCIncludePath2: ..\..; ..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST; ..\..\PFC_Application\interface; ..\..\PFC_Application\inc; ..\..\MCLibrary\interface; ..\..\MCLibrary\interface\common\; ..\..\MCApplication\; ..\..\MCApplication\inc\; ..\..\MCApplication\interface\; ..\..\SystemDriveParams\; ..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Project; ..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MC architecture.srec
  ILINK.IlinkOutputFile: MC architecture.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../SystemDriveParams/: PFCParameters.h
  group interface
    ../../PFC_Application/interface/: PFCApplication.h PFCInit.h STM32F10x_PFCApplication.h
  group obj
    ../../PFC_Application/obj/: STM32F10x_PFCApplication.o
  group src
    ../../PFC_Application/src/: STM32F10x_PFCInit.c
