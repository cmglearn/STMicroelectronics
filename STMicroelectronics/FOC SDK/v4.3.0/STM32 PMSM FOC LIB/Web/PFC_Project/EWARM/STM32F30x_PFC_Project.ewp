# IAR project STM32F30x_PFC_Project.ewp, settings and files
configuration RELEASE (ARM)
  General.OGChipSelectEditMenu: STM32F303xB ST STM32F303xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: ..\; ..\..\PFC_Application\interface; ..\..\PFC_Application\inc; ..\..\MCLibrary; ..\..\MClibrary\interface\; ..\..\MCLibrary\interface\common; ..\..\MCApplication\; ..\..\MCApplication\inc\; ..\..\MCApplication\interface\; ..\..\SystemDriveParams; ..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F30x\Include; ..\..\..\Common\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\Project; ..\..\UILibrary\interface\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MC architecture.srec
  ILINK.IlinkOutputFile: MC architecture.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../SystemDriveParams/: PFCParameters.h
  group interface
    ../../PFC_Application/interface/: PFCApplication.h PFCInit.h STM32F30x_PFCApplication.h
  group obj
    ../../PFC_Application/obj/: STM32F30x_PFCApplication.o
  group src
    ../../PFC_Application/src/: STM32F30x_PFCInit.c
