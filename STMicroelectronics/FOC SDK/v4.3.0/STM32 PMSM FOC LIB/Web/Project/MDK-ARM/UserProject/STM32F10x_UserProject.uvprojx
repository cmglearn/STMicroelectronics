# Keil uVision project STM32F10x_UserProject.uvprojx, settings and files
target STM32100B-EVAL (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100B-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL, USE_STM32100B_EVAL, ARM_MATH_CM3
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM32100B_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1fff
  group MCLibrary_interface_common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group MCLibrary_interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h HALL_SpeednPosFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h NTC_TemperatureSensorClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h MTPACtrlClass.h OpenLoopClass.h
  group MCLibrary_lib
    ../MC_Library_Compiled/STM32F10x_SD/: MC_Library_STM32F10x_single_drive.lib
    ../MC_Library_Compiled/STM32F10x_DD/: MC_Library_STM32F10x_dual_drive.lib
  group MCApplication_interface
    ../../../MCApplication/interface/: MCInterfaceClass.h MCTasks.h MCTuningClass.h MC.h
  group MCApplication_private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group MCApplication_src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group CMSIS
    ../../../../Common/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    ../../../../Common/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c misc.c
  group STM32_EVAL
    ../../../../Common/Libraries/STM32_EVAL/: stm32_eval.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
  group RVMDK
    ../../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group UILibrary_interface
    ../../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h LCDVintage_UserInterfaceClass.h UnidirectionalFastCom_UserInterfaceClass.h
  group UILibrary_private
    ../../../UILibrary/inc/: DAC_F30X_UserInterfacePrivate.h DAC_UserInterfacePrivate.h DACRCTIMER_UserInterfacePrivate.h DACSPI_UserInterfacePrivate.h DACSPIAD7303_UserInterfacePrivate.h DACSPIAD7303DUAL_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCD_Interface.h LCDManager_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h UnidirectionalFastCom_UserInterfacePrivate.h
  group UILibrary_src
    ../../../UILibrary/src/: DAC_UserInterfaceClass.c DACRCTIMER_UserInterfaceClass.c DACSPI_UserInterfaceClass.c DACSPIAD7303_UserInterfaceClass.c FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c USART_PhysicalLayerCommunication_Class.c UserInterfaceClass.c LCDVintage_UserInterfaceClass.c UnidirectionalFastCom_UserInterfaceClass.c
  group Project
    ../../: main.c UITask.c stm32f10x_it.c Timebase.c GAPApplication.c
    ../../../SystemDriveParams/: stm32f10x_MC_it.c
  group System & Drive Params
    ../../../SystemDriveParams/: Control stage parameters motor 2.h Control stage parameters.h Drive parameters motor 2.h Drive parameters.h Parameters conversion motor 2.h Parameters conversion.h Parameters conversion_F10X motor 2.h Parameters conversion_F10X.h PMSM motor 2 parameters.h PMSM motor parameters.h Power stage parameters motor 2.h Power stage parameters.h SystemNDriveParams.h
  group Doc
    ./: readme.txt
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL, ARM_MATH_CM3
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM3210E_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6ffff
  memory RVCT9: RAM 0x20000000 size 0xdfff
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL, ARM_MATH_CM3
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM3210B_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
target STEVAL-IHM022V1_DUALDRIVE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: STEVAL-IHM022V1_DUALDRIVE
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STEVAL_IHM022V1, ARM_MATH_CM3
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STEVAL-IHM022V1;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6ffff
  memory RVCT9: RAM 0x20000000 size 0xdfff
target STEVAL-IHM022V1_SINGLEDRIVE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: STEVAL-IHM022V1_SINGLEDRIVE
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6ffff
  memory RVCT9: RAM 0x20000000 size 0xdfff
