# IAR project STM32F0xx_UserProject.ewp, settings and files
configuration STM320518-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; USE_STM320518_EVAL; ARM_MATH_CM0
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\\CMSIS_2_x\Device\ST\STM32F0xx\Include; ..\..\..\..\Common\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM320518_EVAL; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F0xx_UserProject.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32072B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  ILINK.IlinkIcfFile: stm32f072x_flash.icf
configuration STM32F030 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
configuration STM32SPIN (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F031x6 ST STM32F031x6
  group (top)
    ../../: main.c stm32f0xx_it.c Timebase.c UITask.c
    ../../../: readme.txt
    ../../../SystemDriveParams/: stm32f0xx_MC_it.c
  group Motor control/MC Application/interface
    ../../../MCApplication/interface/: MC.h MCInterfaceClass.h MCTasks.h MCTuningClass.h
  group Motor control/MC Application/private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group Motor control/MC Application/src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group Motor control/MC Library/interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HALL_SpeednPosFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_F0XX_PWMnCurrFdbkClass.h R1_SD_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group Motor control/MC Library/interface/common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group Motor control/MC Library/lib
    ../MC Library Compiled/Exe/: MC_Library_STM32F0xx_single_drive.a
  group Motor control/System & Drive Params
    ../../../SystemDriveParams/: Parameters conversion_F0xx.h SystemNDriveParams.h
  group Motor control/System & Drive Params/Motor1
    ../../../SystemDriveParams/: Control stage parameters.h Drive parameters.h Parameters conversion.h PMSM motor parameters.h Power stage parameters.h
  group Std project template/CMSIS
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Std project template/EWARMv5
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group Std project template/StdPeriph_Driver
    ../../../../Common/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Std project template/STM32_EVAL/STM320518-EVAL
    ../../../../Common/Libraries/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_lcd.c
  group User interface/UI Library/interface
    ../../../UILibrary/interface/: DAC_F0X_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h LCDVintage_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h UnidirectionalFastCom_UserInterfaceClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group User interface/UI Library/private
    ../../../UILibrary/inc/: DAC_F0X_UserInterfacePrivate.h DACRCTIMER_UserInterfacePrivate.h DACSPI_UserInterfacePrivate.h DACSPIAD7303_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCDManager_UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h UnidirectionalFastCom_UserInterfacePrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h
  group User interface/UI Library/src
    ../../../UILibrary/src/: DAC_F072_UserInterfaceClass.c DAC_F0XX_UserInterfaceClass.c FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c LCDVintage_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c UnidirectionalFastCom_F0XX_UserInterfaceClass.c USART_F0XX_PhysicalLayerCommunication_Class.c UserInterfaceClass.c
