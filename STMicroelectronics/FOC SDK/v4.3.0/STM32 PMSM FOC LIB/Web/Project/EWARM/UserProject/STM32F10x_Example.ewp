# IAR project STM32F10x_Example.ewp, settings and files
configuration STM3210E_EVAL - Potentiometer (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_POTENTIOMETER
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM3210E_EVAL; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\PFC_Application\interface\; ..\..\..\PFC_Application\inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10xE_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\PFC_Project\EWARM\PFC Application Compiled\Exe\PFC_Project.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210E_EVAL - Ramp (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_RAMP
configuration STM3210E_EVAL - PI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_PI
configuration STM3210E_EVAL - MODE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_CONTROLMODE
configuration STM3210E_EVAL - SPEED (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_SPEEDMONITOR
configuration STEVAL-IFN003V1-Potentiometer (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_POTENTIOMETER
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM3210B_EVAL; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\PFC_Application\interface\; ..\..\..\PFC_Application\inc\
configuration STM3210B_EVAL - Ramp (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_RAMP
  ICCARM.CCIncludePath2: as above
configuration STM3210B_EVAL - PI (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_PI
  ICCARM.CCIncludePath2: as above
configuration STM3210B_EVAL - MODE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_CONTROLMODE
  ICCARM.CCIncludePath2: as above
configuration STM3210B_EVAL - SPEED (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL; ARM_MATH_CM3; MC_EXAMPLE; EXAMPLE_SPEEDMONITOR
  ICCARM.CCIncludePath2: as above
  group (top)
    ../../: main.c stm32f10x_it.c Timebase.c UITask.c
    ../../../: readme.txt
    ../../../SystemDriveParams/: stm32f10x_MC_it.c
  group Examples
    ../../STM32_SDK_Examples/PI Regulation and Sensor type/: PI_Sensor_onFLY_F1.c
    ../../STM32_SDK_Examples/Potentiometer/: potentiometer_F1.c
    ../../STM32_SDK_Examples/Ramp/: ramp_F1.c
    ../../STM32_SDK_Examples/Speed monitor/: Speed monitor_F1.c
    ../../STM32_SDK_Examples/Torque and Speed mode/: TqSpeedMode_F1.c
  group Motor control/MC Application/interface
    ../../../MCApplication/interface/: MC.h MCInterfaceClass.h MCTasks.h MCTuningClass.h
    ../../../MCApplication/inc/: MCTaskFunction.h
  group Motor control/MC Application/private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group Motor control/MC Application/src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTaskFunction.c MCTasks.c MCTuningClass.c
  group Motor control/MC Library/interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HALL_SpeednPosFdbkClass.h ICS_DD_PWMnCurrFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_DD_PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_DD_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group Motor control/MC Library/interface/common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group Motor control/MC Library/lib
    ../MC Library Compiled/Exe/: MC_Library_STM32F10x_dual_drive.a MC_Library_STM32F10x_single_drive.a
  group Motor control/System & Drive Params
    ../../../SystemDriveParams/: Parameters conversion_F10X motor 2.h Parameters conversion_F10X.h SystemNDriveParams.h
  group Motor control/System & Drive Params/Motor1
    ../../../SystemDriveParams/: Control stage parameters.h Drive parameters.h Parameters conversion.h PMSM motor parameters.h Power stage parameters.h
  group Motor control/System & Drive Params/Motor2
    ../../../SystemDriveParams/: Control stage parameters motor 2.h Drive parameters motor 2.h Parameters conversion motor 2.h PMSM motor 2 parameters.h Power stage parameters motor 2.h
  group Std project template/CMSIS
    ../../../../Common/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Std project template/Doc
    ./: readme.txt
  group Std project template/EWARMv5
    ../../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group Std project template/StdPeriph_Driver
    ../../../../Common/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Std project template/STM32_EVAL
    ../../../../Common/Libraries/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/: stm32_eval.c
  group User interface/UI Library/interface
    ../../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group User interface/UI Library/private
    ../../../UILibrary/inc/: DAC_UserInterfacePrivate.h DACRCTIMER_UserInterfacePrivate.h DACSPI_UserInterfacePrivate.h DACSPIAD7303_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCDManager_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h
  group User interface/UI Library/src
    ../../../UILibrary/src/: DAC_UserInterfaceClass.c DACRCTIMER_UserInterfaceClass.c DACSPI_UserInterfaceClass.c DACSPIAD7303_UserInterfaceClass.c FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c USART_PhysicalLayerCommunication_Class.c UserInterfaceClass.c
