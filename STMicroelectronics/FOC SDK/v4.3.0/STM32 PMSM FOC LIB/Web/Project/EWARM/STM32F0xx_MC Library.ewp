# IAR project STM32F0xx_MC Library.ewp, settings and files
configuration STM32F0xx_SINGLE_DRIVE (ARM)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; MC_LIBRARY_SINGLE
  ICCARM.CCIncludePath2: ..\; ..\..\MCLibrary\; ..\..\MCLibrary\inc\; ..\..\MCLibrary\interface\; ..\..\MCLibrary\interface\common\; ..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F0xx\Include\; ..\..\..\Common\Libraries\STM32F0xx_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MC architecture.srec
  ILINK.IlinkOutputFile: MC architecture.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F0xx/Include/: stm32f0xx.h
  group MC Library
    ../../MCLibrary/: MCLibraryConf.h
  group MC Library/interface
    ../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HALL_SpeednPosFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_F0XX_PWMnCurrFdbkClass.h R3_F0XX_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group MC Library/interface/common
    ../../MCLibrary/interface/common/: DigitalOutputClass.h FastDivClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h RampExtMngrClass.h RampMngrClass.h
  group MC Library/obj/Single Drive CM0
    ../../MCLibrary/obj/CM0/Single Drive/: FastDivClass.o FeedForwardCtrlClass.o FluxWeakeningCtrlClass.o MTPACtrlClass.o RevupCtrlClass.o STO_CORDIC_SpeednPosFdbkClass.o STO_SpeednPosFdbkClass.o
  group MC Library/private
    ../../MCLibrary/inc/: BusVoltageSensorPrivate.h DigitalOutputPrivate.h EncAlignCtrlPrivate.h InrushCurrentLimiterPrivate.h MCIRQHandlerPrivate.h MotorPowerMeasurementPrivate.h NTC_TemperatureSensorPrivate.h PID_PIRegulatorPrivate.h PIRegulatorPrivate.h PQD_MotorPowerMeasurementPrivate.h PWMnCurrFdbkPrivate.h R1_F0XX_PWMnCurrFdbkPrivate.h R3_F0XX_PWMnCurrFdbkPrivate.h RampExtMngrPrivate.h RampMngrPrivate.h Rdivider_BusVoltageSensorPrivate.h RevupCtrlPrivate.h SpeednPosFdbkPrivate.h SpeednTorqCtrlPrivate.h StateMachinePrivate.h TemperatureSensorPrivate.h Virtual_BusVoltageSensorPrivate.h Virtual_TemperatureSensorPrivate.h VirtualSpeedSensor_SpeednPosFdbkPrivate.h
  group MC Library/src
    ../../MCLibrary/src/: BusVoltageSensorClass.c CircleLimitationClass.c DigitalOutputClass_F0XX.c ENC_F0xx_SpeednPosFdbkClass.c EncAlignCtrlClass.c HALL_F0xx_SpeednPosFdbkClass.c InrushCurrentLimiterClass.c MC_Math.c MCIRQHandlerClass.c MotorPowerMeasurementClass.c NTC_F0XX_TemperatureSensorClass.c OpenLoopClass.c PID_PIRegulatorClass.c PIRegulatorClass.c PQD_MotorPowerMeasurementClass.c PWMnCurrFdbkClass.c R1_F0XX_PWMnCurrFdbkClass.c R3_F0XX_PWMnCurrFdbkClass.c RampExtMngrClass.c RampMngrClass.c Rdivider_F0XX_BusVoltageSensorClass.c SpeednPosFdbkClass.c SpeednTorqCtrlClass.c StateMachineClass.c TemperatureSensorClass.c Virtual_BusVoltageSensorClass.c Virtual_TemperatureSensorClass.c VirtualSpeedSensor_SpeednPosFdbkClass.c
